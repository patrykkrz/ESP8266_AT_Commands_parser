# Keil uVision project 01-EXAMPLE_NETWORK_SCAN_RTOS.uvprojx, settings and files
target STM32F429_DISCOVERY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F429xx,USE_HAL_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1,STM32F4XX,STM32F429_DISCOVERY,HSE_VALUE=8000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLSOURCE=RCC_PLLSOURCE_HSE,RCC_PLLM=8,RCC_PLLN=360,RCC_PLLP=2,RCC_PLLQ=7,
  c include: .\User;.\TM;..\00-STM32_LIBRARIES;..\00-HAL_DRIVERS\STM32F4xx_HAL_Driver\Inc;..\00-HAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;..\00-HAL_DRIVERS\CMSIS\Include;..\00-ESP8266_LIBRARY;..\00-ESP8266_LIBRARY\pt;..\00-STM32_LIBRARIES\FreeRTOS\include;..\00-STM32_LIBRARIES\FreeRTOS\CMSIS_RTOS;..\00-STM32_LIBRARIES\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../00-HAL_DRIVERS/CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h
    ../00-HAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
    ../00-HAL_DRIVERS/CMSIS/Device/ST/STM32F7xx/Include/: stm32f7xx.h
  group STM32F4_Startup
    ../00-HAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xc.s startup_stm32f401xe.s startup_stm32f407xx.s startup_stm32f411xe.s startup_stm32f429xx.s startup_stm32f439xx.s startup_stm32f446xx.s
  group STM32F7_Startup
    ../00-HAL_DRIVERS/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f746xx.s startup_stm32f769xx.s
  group STM32F4_HAL_Drivers
    ../00-HAL_DRIVERS/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group STM32F7_HAL_Drivers
    ../00-HAL_DRIVERS/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c
  group TM
    ../00-STM32_LIBRARIES/: tm_stm32_rcc.c tm_stm32_gpio.c tm_stm32_delay.c tm_stm32_disco.c tm_stm32_buffer.c tm_stm32_usart.c tm_stm32_general.c tm_stm32_dma.c tm_stm32_usart_dma.c
  group User
    ./User/: main.c stm32fxxx_it.c system_stm32f0xx.c system_stm32f4xx.c system_stm32f7xx.c
  group ESP
    ../00-ESP8266_LIBRARY/: buffer.c esp8266.c
    ./User/: esp8266_ll.c
  group FreeRTOS
    ../00-STM32_LIBRARIES/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../00-STM32_LIBRARIES/FreeRTOS/portable/RVDS/ARM_CM4F/: port_cm4.c
    ../00-STM32_LIBRARIES/FreeRTOS/portable/RVDS/ARM_CM7/: port_cm7.c
    ../00-STM32_LIBRARIES/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
    ../00-STM32_LIBRARIES/FreeRTOS/portable/MemMang/: heap_4.c
target STM32F4_DISCOVERY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F407xx,USE_HAL_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1,STM32F4XX,STM32F4_DISCOVERY,HSE_VALUE=8000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLM=8,RCC_PLLN=336,RCC_PLLP=2,RCC_PLLQ=7,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target NUCLEO_F411 HSE 8MHz (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F411xE,USE_HAL_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1,STM32F4XX,NUCLEO_F411,HSE_VALUE=8000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLM=8,RCC_PLLN=400,RCC_PLLP=4,RCC_PLLQ=7,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --callgraph
target STM32F7_DISCOVERY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F746xx,USE_HAL_DRIVER,ARM_MATH_CM7,__FPU_PRESENT=1,STM32F7XX,STM32F7_DISCOVERY,HSE_VALUE=25000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLSOURCE=RCC_PLLSOURCE_HSE,RCC_PLLM=25,RCC_PLLN=432,RCC_PLLP=2,RCC_PLLQ=9
  c include: .\User;.\TM;..\00-STM32_LIBRARIES;..\00-HAL_DRIVERS\STM32F7xx_HAL_Driver\Inc;..\00-HAL_DRIVERS\CMSIS\Device\ST\STM32F7xx\Include;..\00-HAL_DRIVERS\CMSIS\Include;..\00-ESP8266_LIBRARY;..\00-ESP8266_LIBRARY\pt;..\00-STM32_LIBRARIES\FreeRTOS\include;..\00-STM32_LIBRARIES\FreeRTOS\CMSIS_RTOS;..\00-STM32_LIBRARIES\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
target STM32F769_DISCOVERY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F769xx,USE_HAL_DRIVER,ARM_MATH_CM7,__FPU_PRESENT=1,STM32F7XX,STM32F769_DISCOVERY,HSE_VALUE=25000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLSOURCE=RCC_PLLSOURCE_HSE,RCC_PLLM=25,RCC_PLLN=432,RCC_PLLP=2,RCC_PLLQ=9
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
